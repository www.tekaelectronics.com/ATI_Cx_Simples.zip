Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Versão 1.0
Time: 2022-10-13T13:17:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 13 13:17:47 2022 * Host: LAPTOP-G6NCF4J6 * Database: C:\Users\ASUS\AppData\Local\Temp\a17f7417-a31b-4431-9848-33469b493b9a\3f07e3fa-f35a-4e51-b3f6-e6262442f8db\ifc * Database version: 5507 * Database creation date: Thu Oct 13 13:17:46 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 13 13:17:47 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 13 13:17:47 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Versão 1.0
LongName: BIM Elements; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_438451
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcElectricDistributionPoint: TEKA_ATI_Telecom_Box_436x123x341_PT:TEKA_ATI_Telecom_Box_436x123x341_PT, 36
In: Level 1
Material: Plástico ABS V0 LSZH, RAL 9018, Plastico RAL 9006
Pset_DistributionFlowElementCommon - Reference: TEKA_ATI_Telecom_Box_436x123x341_PT; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: TEKA
Pset_ProductRequirements - Category: Electrical Equipment
01 GERAL - 01.01 Fabricante: Teka; 01.02 Modelo: 2901076; 01.03 Gama: ATI; 01.04 Familia: ATI embebido; 01.05 Produto: ATI3; 01.06 Descricao: Caixa Base Simples ATI 3 Play Série 15"; 01.07 Mark_ID: ATI; 01.08 Autor: ACADBIM
02 MATERIAIS - 02.01 Cor_Caixa: Branco (RAL 9003); 02.02 Material_Caixa: Plástico ABS V0 LSZH; 02.03 Material_Porta_Frontal: Plástico ABS V0 LSZH; 02.04 Tratamento_Superficie: -
03 TECNICAS - 03.01 Dimensoes: 436 x 123 x 341; 03.02 Carga_Maxima [Kg]: -; 03.03 Unidades_Rack [Un]: -; 03.04 Original Family Name: TEKA_ATI_Telecom_Box_436x123x341_PT: TEKA_ATI_Telecom_Box_436x123x341_PT
